FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	    file://timeout.cfg \
            file://rdkb.cfg \
           "

